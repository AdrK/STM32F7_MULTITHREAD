# Keil uVision project STM32F7_Multithread_Training.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F7_Multithread_Training
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: debug_mode
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c Analyzer.c Analyzer.h Thread1.c Thread2.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:Drivers:Touch Screen 1.0.0, Board Support:LED 1.0.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, Device:STM32Cube Framework:Classic 1.0.0, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:DMA 1.0.1, Device:STM32Cube HAL:DMA2D 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:I2C 1.0.1, Device:STM32Cube HAL:LTDC 1.0.1, Device:STM32Cube HAL:PWR 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:STM32Cube HAL:SDRAM 1.0.1, Device:STM32Cube HAL:UART 1.0.1, Device:Startup 1.0.1, Graphics Display:STM32F746G-Discovery 1.0.0, Graphics:CORE 5.30.0
